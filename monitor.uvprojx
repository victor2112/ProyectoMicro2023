# Keil uVision project monitor.uvprojx, settings and files
target STM32F303K8 (6190000::V6.19::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: monitor
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Monitor
    ./: main.c assembler_functions.h assemblerFunctions.s commands.h memory_display.s memory_modify.s usart_utils.h utils.h call.s call.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
